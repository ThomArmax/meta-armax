RDEPENDS_${PN} += " \
        qt-armax-dev \
        qtxbee-dev \
        hupnp-qt5-dev \
        hupnp-av-qt5-dev \
"
