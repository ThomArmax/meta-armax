PACKAGECONFIG_append = " glib"
